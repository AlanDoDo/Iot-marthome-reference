# Keil uVision project stm32f103.uvproj, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103 +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\core;.\fwlib\inc;.\EDP;.\hardware\inc;.\user;.\NET\onenet\inc;.\NET\device\inc;.\NET\HTTP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ./core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ./core/startup/arm/: startup_stm32f10x_hd.s
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group hardware
    ./hardware/src/: beep.c delay.c usart.c
  group user
    ./user/: main.c
  group OneNET
    ./NET/onenet/src/: onenet.c
  group net_protocol
    ./NET/HTTP/: HttpKit.c
  group net_device
    ./NET/device/src/: esp8266.c
